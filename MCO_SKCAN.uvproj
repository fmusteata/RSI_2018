# Keil uVision project MCO_SKCAN.uvproj, settings and files
target SK CANOpen (MCS-51)
  device: C515C-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(10000000) XRAM (0xF800-0xFFFF) MOD517DP
  output: MCO_SKCAN +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\MCO;..\SKCAN\Include
  group CANOpen stack
    ../MCO/: mco.c mcohwSKCAN.c
  group SKCAN HW
    ./: rSKCANio.c
    ../SKCAN/Drivere/: lcd.c
  group Aplicatie
    ./: mainSKCAN.c user_SKCAN.c
